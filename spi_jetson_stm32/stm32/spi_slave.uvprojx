# Keil uVision project spi_slave.uvprojx, settings and files
target Jetson_SPI_Slave (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: spi_slave +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\vendor\hal_example\User;..\vendor\hal_example\Drivers;..\vendor\hal_example\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\vendor\hal_example\Drivers\CMSIS\Include;..\vendor\hal_example\Drivers\STM32F4xx_HAL_Driver\Inc;.;..\common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../vendor/hal_example/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ./: main.c
    ../vendor/hal_example/User/: stm32f4xx_it.c
    ../vendor/hal_example/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/SYSTEM
    ../vendor/hal_example/Drivers/SYSTEM/delay/: delay.c
    ../vendor/hal_example/Drivers/SYSTEM/sys/: sys.c
    ../vendor/hal_example/Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../vendor/hal_example/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c
  group Drivers/BSP
    ../vendor/hal_example/Drivers/BSP/LED/: led.c
  group Readme
    ../vendor/hal_example/: readme.txt
  group SPI protocol and slave
    ./: spi_slave.c
    ../common/: protocol.c service.c commands.c
